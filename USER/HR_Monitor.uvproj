# Keil uVision project HR_Monitor.uvproj, settings and files
target HR_Monitor (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HR_Monitor +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE\ADC;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\TIMER;..\HARDWARE\OLED;..\HARDWARE\HC05;..\HARDWARE\USART2;..\HARDWARE\RTC;..\USMART;..\HARDWARE\ITEMP;..\HARDWARE\DMA
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/HC05/: hc05.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/ITEMP/: tsensor.c
    ../HARDWARE/DMA/: dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
